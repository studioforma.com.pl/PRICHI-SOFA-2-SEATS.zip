Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Prichi - Sofa - ver4.ifc
Time: 2024-01-15T09:48:54
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (54)
Name
 | Prichi - Sofa model_0 - ObjectType: SketchupGroup
 | Prichi - Sofa model_1 - ObjectType: SketchupGroup
 | Prichi - Sofa model_2 - ObjectType: SketchupGroup
 | Prichi - Sofa model_3 - ObjectType: SketchupGroup
 | Prichi - Sofa model_4 - ObjectType: SketchupGroup
 | Prichi - Sofa model_5 - ObjectType: SketchupGroup
 | Prichi - Sofa model_6 - ObjectType: SketchupGroup
 | Prichi - Sofa model_7 - ObjectType: SketchupGroup
 | Prichi - Sofa model_8 - ObjectType: SketchupGroup
 | Prichi - Sofa model_9 - ObjectType: SketchupGroup
 | Prichi - Sofa model_10 - ObjectType: SketchupGroup
 | Prichi - Sofa model_11 - ObjectType: SketchupGroup
 | Prichi - Sofa model_12 - ObjectType: SketchupGroup
 | Prichi - Sofa model_13 - ObjectType: SketchupGroup
 | Prichi - Sofa model_14 - ObjectType: SketchupGroup
 | Prichi - Sofa model_15 - ObjectType: SketchupGroup
 | Prichi - Sofa model_16 - ObjectType: SketchupGroup
 | Prichi - Sofa model_17 - ObjectType: SketchupGroup
 | Prichi - Sofa model_18 - ObjectType: SketchupGroup
 | Prichi - Sofa model_19 - ObjectType: SketchupGroup
 | Prichi - Sofa model_20 - ObjectType: SketchupGroup
 | Prichi - Sofa model_21 - ObjectType: SketchupGroup
 | Prichi - Sofa model_22 - ObjectType: SketchupGroup
 | Prichi - Sofa model_23 - ObjectType: SketchupGroup
 | Prichi - Sofa model_24 - ObjectType: SketchupGroup
 | Prichi - Sofa model_25 - ObjectType: SketchupGroup
 | Prichi - Sofa model_26 - ObjectType: SketchupGroup
 | Prichi - Sofa model_27 - ObjectType: SketchupGroup
 | Prichi - Sofa model_28 - ObjectType: SketchupGroup
 | Prichi - Sofa model_29 - ObjectType: SketchupGroup
 | Prichi - Sofa model_30 - ObjectType: SketchupGroup
 | Prichi - Sofa model_31 - ObjectType: SketchupGroup
 | Prichi - Sofa model_32 - ObjectType: SketchupGroup
 | Prichi - Sofa model_33 - ObjectType: SketchupGroup
 | Prichi - Sofa model_34 - ObjectType: SketchupGroup
 | Prichi - Sofa model_35 - ObjectType: SketchupGroup
 | Prichi - Sofa model_36 - ObjectType: SketchupGroup
 | Prichi - Sofa model_37 - ObjectType: SketchupGroup
 | Prichi - Sofa model_38 - ObjectType: SketchupGroup
 | Prichi - Sofa model_39 - ObjectType: SketchupGroup
 | Prichi - Sofa model_40 - ObjectType: SketchupGroup
 | Prichi - Sofa model_41 - ObjectType: SketchupGroup
 | Prichi - Sofa model_42 - ObjectType: SketchupGroup
 | Prichi - Sofa model_43 - ObjectType: SketchupGroup
 | Prichi - Sofa model_44 - ObjectType: SketchupGroup
 | Prichi - Sofa model_45 - ObjectType: SketchupGroup
 | Prichi - Sofa model_46 - ObjectType: SketchupGroup
 | Prichi - Sofa model_47 - ObjectType: SketchupGroup
 | Prichi - Sofa model_48 - ObjectType: SketchupGroup
 | Prichi - Sofa model_49 - ObjectType: SketchupGroup
 | Prichi - Sofa model_50 - ObjectType: SketchupGroup
 | Prichi - Sofa model_51 - ObjectType: SketchupGroup
 | Prichi - Sofa model_52 - ObjectType: SketchupGroup
 | Prichi - Sofa model_53 - ObjectType: SketchupGroup
